# Qt fonts are often added here
EXTRA_OECONF += "--with-add-fonts=${libdir}/fonts"
