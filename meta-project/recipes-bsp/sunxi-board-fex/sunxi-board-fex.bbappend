FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-usb-wifi-usbc-num-failed.patch"
