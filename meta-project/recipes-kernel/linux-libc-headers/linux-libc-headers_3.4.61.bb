KORG_ARCHIVE_COMPRESSION = "xz"

require linux-libc-headers.inc

SRC_URI[md5sum] = "11643515c9f3f4c50f8fcbdf6e84d1b4"
SRC_URI[sha256sum] = "cec2aaf0c79e449590bf460b3e4e6880c25736e9f6756f8bbc8173b1d8adf2c7"

